# IAR project JT808.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\0601GB-source\Bios\; $PROJ_DIR$..\..\..\0601GB-source\FWLib\Libraries\CMSIS\Device\ST\STM32F4xx\Include\; $PROJ_DIR$..\..\..\0601GB-source\main\; $PROJ_DIR$..\..\..\0601GB-source\FWLib\Libraries\CMSIS\Include\; $PROJ_DIR$..\..\..\0601GB-source\Flash\; $PROJ_DIR$..\..\..\0601GB-source\Gps\; $PROJ_DIR$..\..\..\0601GB-source\Gsm\; $PROJ_DIR$..\..\..\0601GB-source\Wifi\; $PROJ_DIR$..\..\..\0601GB-source\FWLib\Libraries\STM32F4xx_HAL_Driver\Inc\; $PROJ_DIR$..\..\..\0601GB-source\FS\efsl\inc\; $PROJ_DIR$..\..\..\0601GB-source\FS\fat_fs\inc\; $PROJ_DIR$..\..\..\0601GB-source\CBasicLib\Inc\; $PROJ_DIR$..\..\..\0601GB-source\Include\; $PROJ_DIR$..\..\..\0601GB-source\Usb\STM32_USB_Device_Library\Core\inc\; $PROJ_DIR$..\..\..\0601GB-source\Usb\STM32_USB_Device_Library\Class\cdc\inc\; $PROJ_DIR$..\..\..\0601GB-source\Usb\STM32_USB_OTG_Driver\inc\; $PROJ_DIR$..\..\..\0601GB-source\Usb\UsbVirtualCom\inc\; $PROJ_DIR$..\..\..\0601GB-source\OS\UCOSII\CONFIG\; $PROJ_DIR$..\..\..\0601GB-source\OS\UCOSII\CORE\; $PROJ_DIR$..\..\..\0601GB-source\OS\UCOSII\PORT\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JT808.bin
  ILINK.IlinkOutputFile: JT808.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Alarm
    ../../0601GB-source/Alarm/: Alarm.c
  group Bios
    ../../0601GB-source/Bios/: Bsp.c stm32f4xx_hal_msp.c
  group CBasicLib
    ../../0601GB-source/CBasicLib/Src/: CBasicLib_IAR.a Crc.c Mymalloc.c myqueue.c Pdu.c
  group CMSIS
    ../../0601GB-source/FWLib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CutStateCheck
    ../../0601GB-source/CutStateCheck/: app_CutStateCheck.c dev_CutStateCheck.c
  group EWARM
    ../../0601GB-source/FWLib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xc.s
  group Flash
    ../../0601GB-source/Flash/: Flash.c FlashMidwareStm32.a MiddlewareFlashPort.c spi_flash.c
  group GPS
    ../../0601GB-source/GPS/: app_GPS.c app_GPSManage.c dev_GPS.c NMEA0183Port.c parseNMEA.c
  group Gsm
    ../../0601GB-source/Gsm/: apns.c apnSelfAdaption.c app_Gsm.c app_gsm_Analyse.c app_gsm_Analyse_Expand.c app_gsm_ATLib.c app_gsm_Oper.c app_gsm_Oper_Expand.c app_gsm_Task.c dev_Gsm.c dev_gsm_Database.c GsmDevHalLayer.c GsmDriverApi.c GsmDriverComm.c GsmDriverPortG610.c
  group Led
    ../../0601GB-source/Led/: app_Led.c dev_Led.c
  group LightDistanceSensor
    ../../0601GB-source/LightDistanceSensor/: app_LightDistanceSensor.c dev_I2C.c dev_LightDistanceSensor.c
  group Main
    ../../0601GB-source/Main/: main.c stm32f4xx_it.c
  group Motor
    ../../0601GB-source/Motor/: app_Motor.c dev_Motor.c
  group OS/UCOSII/CORE
    ../../0601GB-source/OS/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group OS/UCOSII/PORT
    ../../0601GB-source/OS/UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Parameter
    ../../0601GB-source/Parameter/: AlarmPara.c CommonPara.c NetPara.c ParameterManage.c SmsPara.c
  group PowerStateCheck
    ../../0601GB-source/PowerStateCheck/: app_PowerChargeCheck.c app_PowerStateCheck.c dev_PowerChargeCheck.c dev_PowerStateCheck.c
  group Protocol
    ../../0601GB-source/Protocol/: ProtocolManage.c SmsProtocol.c SmsProtocolSupport.c TrackerProtocol.c TrackerProtocolSupport.c
  group STM32F4xx_HAL_Driver
    ../../0601GB-source/FWLib/Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Time
    ../../0601GB-source/Time/: app_RTC.c app_TimeManage.c dev_RTC.c
  group Usb
    ../../0601GB-source/Usb/: app_UsbManage.c
  group Usb/STM32_USB_Device_Library/Class/cdc/src
    ../../0601GB-source/Usb/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Usb/STM32_USB_Device_Library/Core/src
    ../../0601GB-source/Usb/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Usb/UsbVirtualCom
    ../../0601GB-source/Usb/UsbVirtualCom/: app_UsbVirtualCom.c dev_UsbVirtualCom.c
  group Usb/UsbVirtualCom/src
    ../../0601GB-source/Usb/UsbVirtualCom/src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Wifi
    ../../0601GB-source/Wifi/: app_WifiSupport.c app_wifiTask.c dev_wifi.c dev_WifiSupport.c esp8266.c wifi_usr_port.c WifiApi.c
